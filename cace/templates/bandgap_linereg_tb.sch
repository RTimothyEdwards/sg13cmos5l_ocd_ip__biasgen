** sch_path: cace/templates/bandgap_linereg_tb.sch
**.subckt bandgap_linereg_tb
Vvss vss GND 0
Vvdd vdd GND DC CACE{Vavdd}
I0 vdd net2 250n
Vdvdd dvdd GND DC CACE{Vdvdd}
I1 vdd net1 1u
x3 vdd vbg vss net2 vtrim[15] vtrim[14] vtrim[13] vtrim[12] vtrim[11] vtrim[10] vtrim[9] vtrim[8]
+ vtrim[7] vtrim[6] vtrim[5] vtrim[4] vtrim[3] vtrim[2] vtrim[1] vtrim[0] vss dvdd dvdd net1
+ sg13cmos5l_ocd_ip__bandgap_v3
C1 vbg GND CACE{Cload} m=1
R1 vbg GND CACE{Rload} m=1
**** begin user architecture code

.option savecurrents
.option TEMP=CACE{temperature}
.control
save all
* NOTE:  Copied from PSRR schematic, needs to be revised for load/line
* regulation.
tran 10u 10m
let psrr = (maximum(vbg) - minimum(vbg)) / 0.02
let psrrdb = 20 * log(abs($&psrr))

echo $&psrrdb > CACE{simpath}/CACE{filename}_{N}.data
.endc


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerPNP.lib CACE{corner_pnp}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_CACE{corner_dio}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{corner_res}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_CACE{corner_cap}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

*** The DUT.  CACE netlists it separately (schematic, layout, pex
*** or rcx, per --source) and only copies the SYMBOL into the run
*** directory, so xschem cannot expand it here and the instance
*** line would otherwise reference an unknown subckt.
.include CACE{DUT_path}



*** Trim thermometer code, one source per bit.
*** The condition is the NUMBER OF BITS SET, 0 to 16, which is all a
*** thermometer code can express.  The two vector sources this
*** replaces could only be all-high or all-low together, which is why
*** every trim setting previously needed a manual schematic edit.
*** NOTE the arithmetic.  CACE[] is evaluated by safe_eval, which
*** allows + - * / % ** and bare math-module calls ONLY --- no
*** comparisons and no conditional expression, so a python
*** conditional is rejected.  copysign(1, x) returns +/-1, so
*** (1 + copysign(1, trim - i - 0.5)) / 2 is 1 when trim > i and
*** 0 otherwise.  The 0.5 keeps the argument off zero, where
*** copysign would return +1 and set the bit one code early.
*** Also note: bare copysign(), NOT math.copysign() --- safe_eval
*** reads the callee as node.func.id and an attribute lookup
*** raises before checkmath() ever sees it.
Vt0  vtrim[0] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 0 - 0.5)) / 2]
Vt1  vtrim[1] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 1 - 0.5)) / 2]
Vt2  vtrim[2] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 2 - 0.5)) / 2]
Vt3  vtrim[3] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 3 - 0.5)) / 2]
Vt4  vtrim[4] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 4 - 0.5)) / 2]
Vt5  vtrim[5] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 5 - 0.5)) / 2]
Vt6  vtrim[6] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 6 - 0.5)) / 2]
Vt7  vtrim[7] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 7 - 0.5)) / 2]
Vt8  vtrim[8] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 8 - 0.5)) / 2]
Vt9  vtrim[9] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 9 - 0.5)) / 2]
Vt10 vtrim[10] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 10 - 0.5)) / 2]
Vt11 vtrim[11] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 11 - 0.5)) / 2]
Vt12 vtrim[12] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 12 - 0.5)) / 2]
Vt13 vtrim[13] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 13 - 0.5)) / 2]
Vt14 vtrim[14] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 14 - 0.5)) / 2]
Vt15 vtrim[15] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 15 - 0.5)) / 2]


**** end user architecture code
**.ends
.GLOBAL GND
.end
