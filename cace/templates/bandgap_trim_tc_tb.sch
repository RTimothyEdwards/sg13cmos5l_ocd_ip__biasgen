** sch_path: cace/templates/bandgap_trim_tc_tb.sch
**.subckt bandgap_trim_tc_tb
Vvss vss GND 0
Vvdd vdd GND 3.3
I0 net2 GND 250n
Vdvdd dvdd GND 1.2
I1 net1 GND 1u
x3 vdd vbg vss net2 vtrim[15] vtrim[14] vtrim[13] vtrim[12] vtrim[11] vtrim[10] vtrim[9] vtrim[8]
+ vtrim[7] vtrim[6] vtrim[5] vtrim[4] vtrim[3] vtrim[2] vtrim[1] vtrim[0] vss dvdd dvdd net1
+ sg13cmos5l_ocd_ip__bandgap_v3
**** begin user architecture code

.option savecurrents
.control
save all
dc temp -40 125 1
*** Calculate tempco
meas dc vbgmax_m40to125 max v(vbg) from=-40 to=125
meas dc vbgmin_m40to125 min v(vbg) from=-40 to=125
meas dc vbgmin_m0to85 min v(vbg) from=0 to=85
meas dc vbgmax_m0to85 max v(vbg) from=0 to=85
meas dc vbg_27 find v(vbg) at=27
meas dc vbg_m40 find v(vbg) at=-40
meas dc vbg_125 find v(vbg) at=125
**
let tempco_m40_125_ppmC=1e6*(vbgmax_m40to125 - vbgmin_m40to125)/165/1.25
let tempco_m0_85_ppmC=1e6*(vbgmax_m0to85 - vbgmin_m0to85)/85/1.25
***
*** SIGNED slope, which the min/max tempco above cannot give.
*** Too much CTAT (low trim) makes this negative, too much PTAT
*** (high trim) positive, so a sign CHANGE between trim=0 and
*** trim=16 proves the flat point lies inside the trim range.
*** That is the bracket test, and it needs no search and no
*** assumption about what the output voltage ought to be.
let vslope_mV=1e3*(vbg_125 - vbg_m40)
**
print tempco_m40_125_ppmC
print tempco_m0_85_ppmC
**
echo $&tempco_m40_125_ppmC $&tempco_m0_85_ppmC $&vbg_27 $&vslope_mV > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOShv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerPNP.lib CACE{corner_pnp}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerDIO.lib dio_CACE{corner_dio}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerRES.lib res_CACE{corner_res}
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerCAP.lib cap_CACE{corner_cap}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sg13cmos5l_stdcell/spice/sg13cmos5l_stdcell.spice

*** The DUT.  CACE netlists it separately (schematic, layout, pex
*** or rcx, per --source) and only copies the SYMBOL into the run
*** directory, so xschem cannot expand it here and the instance
*** line would otherwise reference an unknown subckt.
.include CACE{DUT_path}



*** Trim thermometer code, one source per bit.
*** The condition is the NUMBER OF BITS SET, 0 to 16, which is all a
*** thermometer code can express.  The two vector sources this
*** replaces could only be all-high or all-low together, which is why
*** every trim setting previously needed a manual schematic edit.
*** NOTE the arithmetic.  CACE[] is evaluated by safe_eval, which
*** allows + - * / % ** and bare math-module calls ONLY --- no
*** comparisons and no conditional expression, so a python
*** conditional is rejected.  copysign(1, x) returns +/-1, so
*** (1 + copysign(1, trim - i - 0.5)) / 2 is 1 when trim > i and
*** 0 otherwise.  The 0.5 keeps the argument off zero, where
*** copysign would return +1 and set the bit one code early.
*** Also note: bare copysign(), NOT math.copysign() --- safe_eval
*** reads the callee as node.func.id and an attribute lookup
*** raises before checkmath() ever sees it.
Vt0  vtrim[0] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 0 - 0.5)) / 2]
Vt1  vtrim[1] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 1 - 0.5)) / 2]
Vt2  vtrim[2] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 2 - 0.5)) / 2]
Vt3  vtrim[3] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 3 - 0.5)) / 2]
Vt4  vtrim[4] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 4 - 0.5)) / 2]
Vt5  vtrim[5] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 5 - 0.5)) / 2]
Vt6  vtrim[6] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 6 - 0.5)) / 2]
Vt7  vtrim[7] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 7 - 0.5)) / 2]
Vt8  vtrim[8] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 8 - 0.5)) / 2]
Vt9  vtrim[9] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 9 - 0.5)) / 2]
Vt10 vtrim[10] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 10 - 0.5)) / 2]
Vt11 vtrim[11] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 11 - 0.5)) / 2]
Vt12 vtrim[12] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 12 - 0.5)) / 2]
Vt13 vtrim[13] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 13 - 0.5)) / 2]
Vt14 vtrim[14] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 14 - 0.5)) / 2]
Vt15 vtrim[15] GND CACE[1.2 * (1 + copysign(1, CACE{trim} - 15 - 0.5)) / 2]


**** end user architecture code
**.ends
.GLOBAL GND
.end
